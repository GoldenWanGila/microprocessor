			ORG 	0000h
			MOV 	A, #11111100B
			MOV		SP, #40H
			JMP 	LOOP
			ORG		0040h
LOOP:		MOV		P2, A
			SETB	P1.0
			SETB	P1.1
			JNB		P1.0, PUSH_BLOCK
			JNB		P1.1, POP_BLOCK
CONTINUE:	CALL	DEBOUNCE
			RL		A
			JMP		LOOP
PUSH_BLOCK:	PUSH 	P2
			CALL 	DEBOUNCE
			JMP 	CONTINUE
DEBOUNCE:	MOV 	R2, #250
DE_250_us:	MOV 	R1, #250
			DJNZ 	R1, $
			DJNZ	R2, DE_250_us
			RET
POP_BLOCK:	POP		P2
			CALL 	DEBOUNCE
			JMP		POP_BLOCK
			END